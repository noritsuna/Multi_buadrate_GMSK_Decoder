<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>GMSK_Decoder</value></param>
<param><key>author</key><value>SIProp.org Noritsuna Imamura(noritsuna@siprop.org)</value></param>
<param><key>comment</key><value>&lt;!--
The Multi Buadrate GMSK Decoder
Copyright (c) 2006-2019 SIProp.org Noritsuna Imamura(noritsuna@siprop.org)

Licensed under the Apache License, Version 2.0 (the "License");
you may not use this file except in compliance with the License.
You may obtain a copy of the License at

    http://www.apache.org/licenses/LICENSE-2.0

Unless required by applicable law or agreed to in writing, software
distributed under the License is distributed on an "AS IS" BASIS,
WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
See the License for the specific language governing permissions and
limitations under the License.
--&gt;</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>The Multi Buadrate GMSK Decoder Ver.1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AGC_rate</value></param>
<param><key>value</key><value>1e-4</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>BAUD_RATE_VAL</value></param>
<param><key>value</key><value>9600</value></param>
<param><key>label</key><value>BAUD_RATE</value></param>
<param><key>labels</key><value>["1200bps", "4800bps", "9600bps", "19200bps"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1200, 4800, 9600, 19200]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>CENTER_TUNE_FREQ</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Tune Center Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2000000</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>2000000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONF_DATA_save_file_path</value></param>
<param><key>config_file</key><value>GMSK_Decoder.conf</value></param>
<param><key>value</key><value>recv_data.dat</value></param>
<param><key>option</key><value>DATA_save_file_path</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONF_IQ_recv_file_path</value></param>
<param><key>config_file</key><value>GMSK_Decoder.conf</value></param>
<param><key>value</key><value>IQ_data.wav</value></param>
<param><key>option</key><value>IQ_recv_file_path</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONF_IQ_save_file_path</value></param>
<param><key>config_file</key><value>GMSK_Decoder.conf</value></param>
<param><key>value</key><value>IQ_save_data.wav</value></param>
<param><key>option</key><value>IQ_save_file_path</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONF_IQ_save_header_file_path</value></param>
<param><key>config_file</key><value>GMSK_Decoder.conf</value></param>
<param><key>value</key><value>IQ_data.hdr</value></param>
<param><key>option</key><value>IQ_save_header_file_path</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CONF_LIME_ANALOG_FILTER_rate</value></param>
<param><key>value</key><value>samp_rate*LPF_cut_magnification</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CONF_LIME_CALIBRATION_rate</value></param>
<param><key>value</key><value>samp_rate*LPF_cut_magnification</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONF_LIME_SERIAL</value></param>
<param><key>config_file</key><value>GMSK_Decoder.conf</value></param>
<param><key>value</key><value>XXXXXXXXXXXXXXXXXXXXXXX</value></param>
<param><key>option</key><value>lime_SDR_serial_number</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONF_OSMOCOM_URL</value></param>
<param><key>config_file</key><value>GMSK_Decoder.conf</value></param>
<param><key>value</key><value>rtl=0</value></param>
<param><key>option</key><value>OSMOCOM_URL</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>CONF_PLUTO_URL</value></param>
<param><key>config_file</key><value>GMSK_Decoder.conf</value></param>
<param><key>value</key><value>ip:pluto.local</value></param>
<param><key>option</key><value>PLUTO_URL</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>DS_ENABLE</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>label</key><value>Auto Doopler Shift</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DS_FFT_SIZE</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DS_TUNE_AVG</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DS_cut_rate</value></param>
<param><key>value</key><value>19200*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DS_cut_threshold_rate</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>DS_diff_freq</value></param>
<param><key>block_id</key><value>DS_diff_freq_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DS_diff_freq_VAL</value></param>
<param><key>value</key><value>int(DS_diff_freq&gt;=DS_cut_threshold_rate)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>DS_freq</value></param>
<param><key>block_id</key><value>DS_freq_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DS_freq_VAL</value></param>
<param><key>value</key><value>DS_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LPF_cut_magnification</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LPF_cut_rate</value></param>
<param><key>value</key><value>BAUD_RATE_VAL*LPF_cut_magnification</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RF_GAIN</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_freq</value></param>
<param><key>value</key><value>436.0e6</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>SAVE_DATA</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>label</key><value>Save IQ Data</value></param>
<param><key>true</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>61.44e6/32</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>DS_Freq</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Doppler Shift Freq</value></param>
<param><key>unit1</key><value>Hz</value></param>
<param><key>max</key><value>DS_cut_rate</value></param>
<param><key>min</key><value>-DS_cut_rate</value></param>
<param><key>name</key><value>Doppler Shift Freq</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>DS_diff_freq_probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>DS_freq_probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>AGC_rate</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>DS_freq_VAL</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>DS_TUNE_AVG</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>19200/BAUD_RATE_VAL-1</value></param>
<param><key>num_inputs</key><value>16</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>int(DS_diff_freq_VAL)</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>open</key><value>SAVE_DATA</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_1</value></param>
<param><key>open</key><value>DS_ENABLE</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-DS_FFT_SIZE/2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>DS_FFT_SIZE</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>IQ_save_data.wav</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_meta_source</key>
<param><key>id</key><value>blocks_file_meta_source_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>IQ_data.wav</value></param>
<param><key>hdr_file</key><value>IQ_data.hdr</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>recv_data.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>DS_TUNE_AVG</value></param>
<param><key>max_iter</key><value>DS_TUNE_AVG</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>DS_cut_rate*2/DS_FFT_SIZE</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>(-CENTER_TUNE_FREQ)+(int(DS_freq_VAL))</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>32</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>CONF_LIME_ANALOG_FILTER_rate</value></param>
<param><key>analog_filter_ch0</key><value>1</value></param>
<param><key>cmix_mode_ch0</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>CONF_LIME_CALIBRATION_rate</value></param>
<param><key>calibration_ch0</key><value>1</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_filter_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>RF_GAIN</value></param>
<param><key>lna_path_ch0</key><value>2</value></param>
<param><key>lna_path_mini</key><value>3</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>analog_filter_ch1</key><value>1</value></param>
<param><key>cmix_mode_ch1</key><value>0</value></param>
<param><key>calibr_bandw_ch1</key><value>10e6</value></param>
<param><key>calibration_ch1</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>digital_filter_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>chip_mode</key><value>1</value></param>
<param><key>serial</key><value>CONF_LIME_SERIAL</value></param>
<param><key>device_type</key><value>2</value></param>
<param><key>file_switch</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>RF_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>fft_size</key><value>DS_FFT_SIZE</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>DS_cut_rate*LPF_cut_magnification</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>4800*LPF_cut_magnification</value></param>
<param><key>decim</key><value>int(samp_rate/4800/2)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>4800*LPF_cut_magnification/4</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>DS_cut_rate</value></param>
<param><key>decim</key><value>int(samp_rate/DS_cut_rate)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>DS_cut_rate/4</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_for_1200</value></param>
<param><key>cutoff_freq</key><value>1200*LPF_cut_magnification</value></param>
<param><key>decim</key><value>int(samp_rate/1200/2)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1200*LPF_cut_magnification/4</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_for_19200</value></param>
<param><key>cutoff_freq</key><value>19200*LPF_cut_magnification</value></param>
<param><key>decim</key><value>int(samp_rate/19200/2)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>19200*LPF_cut_magnification/4</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_for_9600</value></param>
<param><key>cutoff_freq</key><value>9600*LPF_cut_magnification</value></param>
<param><key>decim</key><value>int(samp_rate/9600/2)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>9600*LPF_cut_magnification/4</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>RF_GAIN</value></param>
<param><key>freq0</key><value>RF_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>RF_GAIN</value></param>
<param><key>gain0</key><value>RF_GAIN</value></param>
<param><key>args</key><value>rtl=0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value>ip:pluto.local</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>RF_freq</value></param>
<param><key>manual_gain</key><value>RF_GAIN</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>samp_rate/4</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>LPF_cut_rate*LPF_cut_magnification</value></param>
<param><key>fc</key><value>RF_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Data Wave"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>20</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>RF_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Spectrum Wave"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>DS_Freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>DS_freq_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_1</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>DS_diff_freq_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_meta_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_valve_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_for_1200</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_for_19200</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_for_9600</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_for_1200</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>low_pass_filter_for_19200</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_for_9600</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
